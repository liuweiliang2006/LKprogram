# Keil uVision project Adc12chConfigurable_V1.0.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Adc12chConfigurable_V1.0 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD
  c include: ..\User;..\Libraries\core;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\core\temp;..\User\driver;..\User\api;..\User\main;..\User\alg;..\User\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group main
    ../User/main/: main.c hw_init.c hw_lib.h hw_common.c debug.c delay.c
  group core
    ../Libraries/core/: core_cm3.c core_cm3.h hd-ld-md.txt startup_stm32f10x_md.s stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c system_stm32f10x.h startup_stm32f10x_hd.s
  group lib
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group driver
    ../User/driver/: drv_uart.c drv_adc.c drv_sound.c drv_sim800.c drv_led.c drv_gpio_int.c drv_timer.c drv_dog.c drv_systick.c drv_detect.c drv_flash.c
  group api
    ../User/api/: api_sendmessage.c api_adc.c api_battery.c api_sound.c api_door.c api_shake.c api_flash.c api_delay_timer.c dataprocess.lib api_result.c api_communicate.c
  group Doc
    ../User/Doc/: readme.txt
